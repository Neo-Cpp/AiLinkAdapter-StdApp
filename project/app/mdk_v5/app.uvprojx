# Keil uVision project app.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.1.1
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf --bin --output=.\app .\objects_fs\app.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=1 wLevel=2
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1,OTG_USE_DMA
  c include: ..\..\..\libraries\cmsis\cm4\core_support;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\drivers\inc;..\..\board;..\inc;..\..\..\middlewares\usb_drivers\inc;..\..\..\middlewares\usbd_class\cdc;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM4F;..\..\..\middlewares\i2c_application_library;..\..\..\middlewares\usbd_class\audio;..\..\..\middlewares\usbd_class\cdrom
  memory RVCT4: ROM 0x8006000 size 0x3a000
  memory RVCT5: ROM 0x90000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: at32f402_405_clock.c at32f402_405_int.c main.c include_port.c audio_codec.c
    ../../../middlewares/i2c_application_library/: i2c_application.c
  group bsp
    ../../board/: board.c al_i2c_smbus.c al_adc_func.c al_board.c al_gpio_func.c al_pwm_func.c al_spi_func.c al_uart_func.c msg_func.c osal_board.c osal_board_api.cpp
  group firmware
    ../../../libraries/drivers/src/: at32f402_405_acc.c at32f402_405_adc.c at32f402_405_can.c at32f402_405_crc.c at32f402_405_crm.c at32f402_405_debug.c at32f402_405_dma.c at32f402_405_ertc.c at32f402_405_exint.c at32f402_405_flash.c at32f402_405_gpio.c at32f402_405_i2c.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_qspi.c at32f402_405_scfg.c at32f402_405_spi.c at32f402_405_tmr.c at32f402_405_usart.c at32f402_405_usb.c at32f402_405_wdt.c at32f402_405_wwdt.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f402_405.s
  group usbd_driver
    ../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class_cdc
    ../../../middlewares/usbd_class/cdc/: cdc_class.c cdc_desc.c
  group usbd_class_audio
    ../../../middlewares/usbd_class/audio/: audio_class.c audio_desc.c
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
